PACKAGECONFIG:append:sun50i = " lima "
